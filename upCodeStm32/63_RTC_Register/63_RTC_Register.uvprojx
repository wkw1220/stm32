# Keil uVision project 63_RTC_Register.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 02_LED_Flow_Register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\User;.\Driver\led;.\Com\delay;.\Driver\usart;.\Driver\fsmc;.\Driver\lcd;.\interface\lcd;.\Driver\rtc;.\Driver\bkp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group User
    ./User/: main.c
  group Driver
    ./Driver/led/: Driver_Led.c
    ./Driver/usart/: Dri_USART.c
    ./Driver/lcd/: Driver_Lcd.c
    ./Driver/bkp/: Driver_bkp.c
    ./Driver/rtc/: Driver_RTC.c
  group Com
    ./Com/delay/: Delay.h Delay.c
  group interface
    ./interface/lcd/: Inf_Lcd.c
