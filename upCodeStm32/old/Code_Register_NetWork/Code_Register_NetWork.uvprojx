# Keil uVision project Code_Register_NetWork.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 02_LED_Flow_Register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\User;.\Com\delay;.\main;.\Driver\usart;.\Driver\spi;.\Int\w5500\w5500_base;.\Int\w5500\w5500_info;.\Driver\gpio;.\Int;.\Int\w5500;.\Driver\led
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group User
    ./User/: main.c
  group Com
    ./Com/delay/: Delay.c
  group Driver
    ./Driver/usart/: Driver_Usart.c
    ./Driver/spi/: Driver_SPI.c
    ./Driver/gpio/: Driver_GPIO.c
    ./Driver/led/: Driver_Led.c
  group Internet
    ./Int/w5500/w5500_base/: dhcp.c httpParser.c httpServer.c httpUtil.c socket.c w5500.c wizchip_conf.c
    ./Int/w5500/w5500_info/: Inf_W5500_Ping.c Inf_Server.c Inf_Client.c Inf_HttpServer.c
