# Keil uVision project Code_Register_Test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01_LED_Register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\User;.\Driver\buzzer;.\Driver\led;.\Com\delay;.\Driver\vibrator;.\Driver\usart;.\Driver\relay;.\Driver\m433
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group User
    ./User/: main.c
  group Deiver
    ./Driver/buzzer/: Driver_Buzzer.c
    ./Driver/led/: Driver_Led.c
    ./Driver/vibrator/: Driver_Vibrator.c
    ./Driver/usart/: Driver_Usart.c Driver_Usart2.c
    ./Driver/relay/: Driver_Relay.c
    ./Driver/m433/: Driver_M433.c
  group com
    ./Com/delay/: Delay.c
