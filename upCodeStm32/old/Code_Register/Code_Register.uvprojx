# Keil uVision project Code_Register.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 02_LED_Flow_Register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\User;.\Driver\led;.\Com\delay;.\main;.\Driver\key;.\Driver\buzzer;.\Driver\usart;.\Int\w24C02;.\Driver\I2C;.\Driver\sysTick;.\Driver\basicTimer;.\Driver\generalTimer;.\Driver\advancedTimer;.\Driver\dma;.\Driver\adc;.\Int\w25Q32;.\Driver\spi;.\Driver\fsmc;.\Driver\lcd;.\Int\lcd;.\Driver\led;.\Int\w5500\w5500_base;.\Int\w5500\w5500_info;.\Driver\gpio;.\Int;.\Int\w5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group User
    ./User/: main.c
  group Com
    ./Com/delay/: Delay.c
  group Int
    ./Int/w24C02/: Int_W24C02.c Int_W24C02_Hard.c
    ./Int/w25Q32/: Int_W25Q32.c
    ./Int/lcd/: Inf_Lcd.c
  group Driver
    ./Driver/buzzer/: Driver_Buzzer.c
    ./Driver/I2C/: Driver_I2C2_HardWare.c Driver_I2C2_Soft.c
    ./Driver/key/: Driver_Key.c
    ./Driver/usart/: Driver_Usart.c
    ./Driver/led/: Driver_Led.c
    ./Driver/sysTick/: Driver_SysTick.c
    ./Driver/basicTimer/: Driver_TIM6.c
    ./Driver/generalTimer/: Driver_Timer5_PWM.c
    ./Driver/dma/: Driver_DMA.c
    ./Driver/adc/: Driver_ADC.c
    ./Driver/spi/: Driver_SPI.c
    ./Driver/fsmc/: Driver_FSMC.c
    ./Driver/lcd/: Driver_Lcd.c
    ./Driver/gpio/: Driver_GPIO.c
  group Internet
    ./Int/w5500/w5500_base/: dhcp.c httpParser.c httpServer.c httpUtil.c socket.c w5500.c wizchip_conf.c
    ./Int/w5500/w5500_info/: Inf_W5500_Ping.c
