<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\67_IWDOG_HAL.ewp</path>
  </project>
  <batchBuild />
</workspace>
